###############################################################
#  Generated by:      Cadence Innovus 23.31-s109_1
#  OS:                Linux x86_64(Host ID ei-vm-018.othr.de)
#  Generated on:      Sat Jun 21 02:13:10 2025
#  Design:            fpga_top
#  Command:           savePartition -dir Partitions -def
###############################################################

VERSION 5.8 ;

BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO grid_clb
  CLASS BLOCK ;
  FOREIGN grid_clb 0.000000 0.000000 ;
  ORIGIN 0.000000 0.000000 ;
  SIZE 643.680000 BY 703.080000 ;
  SYMMETRY X Y R90 ;
  PIN pReset[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END pReset[0]
  PIN prog_clk[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END prog_clk[0]
  PIN set[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END set[0]
  PIN reset[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END reset[0]
  PIN clk[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END clk[0]
  PIN top_width_0_height_0_subtile_0__pin_I_0_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_I_0_[0]
  PIN top_width_0_height_0_subtile_0__pin_I_4_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_I_4_[0]
  PIN top_width_0_height_0_subtile_0__pin_I_8_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_I_8_[0]
  PIN top_width_0_height_0_subtile_0__pin_I_12_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_I_12_[0]
  PIN top_width_0_height_0_subtile_0__pin_I_16_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_I_16_[0]
  PIN top_width_0_height_0_subtile_0__pin_I_20_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_I_20_[0]
  PIN top_width_0_height_0_subtile_0__pin_I_24_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_I_24_[0]
  PIN top_width_0_height_0_subtile_0__pin_I_28_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_I_28_[0]
  PIN top_width_0_height_0_subtile_0__pin_I_32_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_I_32_[0]
  PIN top_width_0_height_0_subtile_0__pin_I_36_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_I_36_[0]
  PIN top_width_0_height_0_subtile_0__pin_clk_0_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_clk_0_[0]
  PIN right_width_0_height_0_subtile_0__pin_I_1_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_I_1_[0]
  PIN right_width_0_height_0_subtile_0__pin_I_5_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_I_5_[0]
  PIN right_width_0_height_0_subtile_0__pin_I_9_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_I_9_[0]
  PIN right_width_0_height_0_subtile_0__pin_I_13_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_I_13_[0]
  PIN right_width_0_height_0_subtile_0__pin_I_17_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_I_17_[0]
  PIN right_width_0_height_0_subtile_0__pin_I_21_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_I_21_[0]
  PIN right_width_0_height_0_subtile_0__pin_I_25_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_I_25_[0]
  PIN right_width_0_height_0_subtile_0__pin_I_29_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_I_29_[0]
  PIN right_width_0_height_0_subtile_0__pin_I_33_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_I_33_[0]
  PIN right_width_0_height_0_subtile_0__pin_I_37_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_I_37_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_I_2_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_I_2_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_I_6_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_I_6_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_I_10_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_I_10_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_I_14_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_I_14_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_I_18_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_I_18_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_I_22_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_I_22_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_I_26_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_I_26_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_I_30_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_I_30_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_I_34_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_I_34_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_I_38_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_I_38_[0]
  PIN left_width_0_height_0_subtile_0__pin_I_3_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_I_3_[0]
  PIN left_width_0_height_0_subtile_0__pin_I_7_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_I_7_[0]
  PIN left_width_0_height_0_subtile_0__pin_I_11_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_I_11_[0]
  PIN left_width_0_height_0_subtile_0__pin_I_15_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_I_15_[0]
  PIN left_width_0_height_0_subtile_0__pin_I_19_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_I_19_[0]
  PIN left_width_0_height_0_subtile_0__pin_I_23_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_I_23_[0]
  PIN left_width_0_height_0_subtile_0__pin_I_27_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_I_27_[0]
  PIN left_width_0_height_0_subtile_0__pin_I_31_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_I_31_[0]
  PIN left_width_0_height_0_subtile_0__pin_I_35_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_I_35_[0]
  PIN left_width_0_height_0_subtile_0__pin_I_39_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_I_39_[0]
  PIN ccff_head[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ccff_head[0]
  PIN top_width_0_height_0_subtile_0__pin_O_0_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_O_0_[0]
  PIN top_width_0_height_0_subtile_0__pin_O_4_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_O_4_[0]
  PIN top_width_0_height_0_subtile_0__pin_O_8_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_O_8_[0]
  PIN top_width_0_height_0_subtile_0__pin_O_12_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_O_12_[0]
  PIN top_width_0_height_0_subtile_0__pin_O_16_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_width_0_height_0_subtile_0__pin_O_16_[0]
  PIN right_width_0_height_0_subtile_0__pin_O_1_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_O_1_[0]
  PIN right_width_0_height_0_subtile_0__pin_O_5_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_O_5_[0]
  PIN right_width_0_height_0_subtile_0__pin_O_9_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_O_9_[0]
  PIN right_width_0_height_0_subtile_0__pin_O_13_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_O_13_[0]
  PIN right_width_0_height_0_subtile_0__pin_O_17_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_width_0_height_0_subtile_0__pin_O_17_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_O_2_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_O_2_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_O_6_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_O_6_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_O_10_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_O_10_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_O_14_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_O_14_[0]
  PIN bottom_width_0_height_0_subtile_0__pin_O_18_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_width_0_height_0_subtile_0__pin_O_18_[0]
  PIN left_width_0_height_0_subtile_0__pin_O_3_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_O_3_[0]
  PIN left_width_0_height_0_subtile_0__pin_O_7_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_O_7_[0]
  PIN left_width_0_height_0_subtile_0__pin_O_11_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_O_11_[0]
  PIN left_width_0_height_0_subtile_0__pin_O_15_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_O_15_[0]
  PIN left_width_0_height_0_subtile_0__pin_O_19_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END left_width_0_height_0_subtile_0__pin_O_19_[0]
  PIN ccff_tail[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ccff_tail[0]
  OBS
    LAYER TopMetal2 ;
      RECT 0.000000 0.000000 643.680000 703.080000 ;
    LAYER TopMetal1 ;
      RECT 0.000000 0.000000 643.680000 703.080000 ;
    LAYER Metal5 ;
      RECT 0.000000 0.000000 643.680000 703.080000 ;
    LAYER Metal4 ;
      RECT 0.000000 0.000000 643.680000 703.080000 ;
    LAYER Metal3 ;
      RECT 0.000000 0.000000 643.680000 703.080000 ;
    LAYER Metal2 ;
      RECT 0.000000 0.000000 643.680000 703.080000 ;
    LAYER Metal1 ;
      RECT 0.000000 0.000000 643.680000 703.080000 ;
  END
END grid_clb

END LIBRARY
