###############################################################
#  Generated by:      Cadence Innovus 23.31-s109_1
#  OS:                Linux x86_64(Host ID ei-vm-018.othr.de)
#  Generated on:      Sat Jun 21 02:18:26 2025
#  Design:            fpga_top
#  Command:           saveDesign fpga_top.enc -tcon
###############################################################

VERSION 5.8 ;

BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO cby_0__1_
  CLASS BLOCK ;
  FOREIGN cby_0__1_ 0.000000 0.000000 ;
  ORIGIN 0.000000 0.000000 ;
  SIZE 103.680000 BY 113.400000 ;
  SYMMETRY X Y R90 ;
  PIN pReset[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END pReset[0]
  PIN prog_clk[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END prog_clk[0]
  PIN chany_bottom_in[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[0]
  PIN chany_bottom_in[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[1]
  PIN chany_bottom_in[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[2]
  PIN chany_bottom_in[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[3]
  PIN chany_bottom_in[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[4]
  PIN chany_bottom_in[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[5]
  PIN chany_bottom_in[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[6]
  PIN chany_bottom_in[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[7]
  PIN chany_bottom_in[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[8]
  PIN chany_bottom_in[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[9]
  PIN chany_top_in[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[0]
  PIN chany_top_in[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[1]
  PIN chany_top_in[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[2]
  PIN chany_top_in[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[3]
  PIN chany_top_in[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[4]
  PIN chany_top_in[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[5]
  PIN chany_top_in[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[6]
  PIN chany_top_in[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[7]
  PIN chany_top_in[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[8]
  PIN chany_top_in[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[9]
  PIN ccff_head[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ccff_head[0]
  PIN chany_bottom_out[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[0]
  PIN chany_bottom_out[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[1]
  PIN chany_bottom_out[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[2]
  PIN chany_bottom_out[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[3]
  PIN chany_bottom_out[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[4]
  PIN chany_bottom_out[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[5]
  PIN chany_bottom_out[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[6]
  PIN chany_bottom_out[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[7]
  PIN chany_bottom_out[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[8]
  PIN chany_bottom_out[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[9]
  PIN chany_top_out[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[0]
  PIN chany_top_out[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[1]
  PIN chany_top_out[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[2]
  PIN chany_top_out[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[3]
  PIN chany_top_out[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[4]
  PIN chany_top_out[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[5]
  PIN chany_top_out[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[6]
  PIN chany_top_out[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[7]
  PIN chany_top_out[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[8]
  PIN chany_top_out[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[9]
  PIN right_grid_left_width_0_height_0_subtile_0__pin_I_3_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_grid_left_width_0_height_0_subtile_0__pin_I_3_[0]
  PIN right_grid_left_width_0_height_0_subtile_0__pin_I_7_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_grid_left_width_0_height_0_subtile_0__pin_I_7_[0]
  PIN right_grid_left_width_0_height_0_subtile_0__pin_I_11_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_grid_left_width_0_height_0_subtile_0__pin_I_11_[0]
  PIN right_grid_left_width_0_height_0_subtile_0__pin_I_15_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_grid_left_width_0_height_0_subtile_0__pin_I_15_[0]
  PIN right_grid_left_width_0_height_0_subtile_0__pin_I_19_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_grid_left_width_0_height_0_subtile_0__pin_I_19_[0]
  PIN right_grid_left_width_0_height_0_subtile_0__pin_I_23_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_grid_left_width_0_height_0_subtile_0__pin_I_23_[0]
  PIN right_grid_left_width_0_height_0_subtile_0__pin_I_27_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_grid_left_width_0_height_0_subtile_0__pin_I_27_[0]
  PIN right_grid_left_width_0_height_0_subtile_0__pin_I_31_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_grid_left_width_0_height_0_subtile_0__pin_I_31_[0]
  PIN right_grid_left_width_0_height_0_subtile_0__pin_I_35_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_grid_left_width_0_height_0_subtile_0__pin_I_35_[0]
  PIN right_grid_left_width_0_height_0_subtile_0__pin_I_39_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END right_grid_left_width_0_height_0_subtile_0__pin_I_39_[0]
  PIN left_grid_right_width_0_height_0_subtile_0__pin_outpad_0_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END left_grid_right_width_0_height_0_subtile_0__pin_outpad_0_[0]
  PIN left_grid_right_width_0_height_0_subtile_1__pin_outpad_0_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END left_grid_right_width_0_height_0_subtile_1__pin_outpad_0_[0]
  PIN left_grid_right_width_0_height_0_subtile_2__pin_outpad_0_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END left_grid_right_width_0_height_0_subtile_2__pin_outpad_0_[0]
  PIN left_grid_right_width_0_height_0_subtile_3__pin_outpad_0_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END left_grid_right_width_0_height_0_subtile_3__pin_outpad_0_[0]
  PIN left_grid_right_width_0_height_0_subtile_4__pin_outpad_0_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END left_grid_right_width_0_height_0_subtile_4__pin_outpad_0_[0]
  PIN left_grid_right_width_0_height_0_subtile_5__pin_outpad_0_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END left_grid_right_width_0_height_0_subtile_5__pin_outpad_0_[0]
  PIN left_grid_right_width_0_height_0_subtile_6__pin_outpad_0_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END left_grid_right_width_0_height_0_subtile_6__pin_outpad_0_[0]
  PIN left_grid_right_width_0_height_0_subtile_7__pin_outpad_0_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END left_grid_right_width_0_height_0_subtile_7__pin_outpad_0_[0]
  PIN ccff_tail[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ccff_tail[0]
  OBS
    LAYER TopMetal2 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
    LAYER TopMetal1 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
    LAYER Metal5 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
    LAYER Metal4 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
    LAYER Metal3 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
    LAYER Metal2 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
    LAYER Metal1 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
  END
END cby_0__1_

END LIBRARY
