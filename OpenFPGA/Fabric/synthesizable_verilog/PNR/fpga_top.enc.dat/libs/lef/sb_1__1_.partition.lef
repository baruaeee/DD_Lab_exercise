###############################################################
#  Generated by:      Cadence Innovus 23.31-s109_1
#  OS:                Linux x86_64(Host ID ei-vm-018.othr.de)
#  Generated on:      Sat Jun 21 02:18:26 2025
#  Design:            fpga_top
#  Command:           saveDesign fpga_top.enc -tcon
###############################################################

VERSION 5.8 ;

BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO sb_1__1_
  CLASS BLOCK ;
  FOREIGN sb_1__1_ 0.000000 0.000000 ;
  ORIGIN 0.000000 0.000000 ;
  SIZE 117.600000 BY 128.520000 ;
  SYMMETRY X Y R90 ;
  PIN pReset[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END pReset[0]
  PIN prog_clk[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END prog_clk[0]
  PIN chany_top_in[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[0]
  PIN chany_top_in[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[1]
  PIN chany_top_in[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[2]
  PIN chany_top_in[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[3]
  PIN chany_top_in[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[4]
  PIN chany_top_in[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[5]
  PIN chany_top_in[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[6]
  PIN chany_top_in[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[7]
  PIN chany_top_in[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[8]
  PIN chany_top_in[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_top_in[9]
  PIN top_left_grid_right_width_0_height_0_subtile_0__pin_O_1_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_left_grid_right_width_0_height_0_subtile_0__pin_O_1_[0]
  PIN top_left_grid_right_width_0_height_0_subtile_0__pin_O_5_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_left_grid_right_width_0_height_0_subtile_0__pin_O_5_[0]
  PIN top_left_grid_right_width_0_height_0_subtile_0__pin_O_9_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_left_grid_right_width_0_height_0_subtile_0__pin_O_9_[0]
  PIN top_left_grid_right_width_0_height_0_subtile_0__pin_O_13_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_left_grid_right_width_0_height_0_subtile_0__pin_O_13_[0]
  PIN top_left_grid_right_width_0_height_0_subtile_0__pin_O_17_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_left_grid_right_width_0_height_0_subtile_0__pin_O_17_[0]
  PIN top_right_grid_left_width_0_height_0_subtile_0__pin_O_3_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_right_grid_left_width_0_height_0_subtile_0__pin_O_3_[0]
  PIN top_right_grid_left_width_0_height_0_subtile_0__pin_O_7_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_right_grid_left_width_0_height_0_subtile_0__pin_O_7_[0]
  PIN top_right_grid_left_width_0_height_0_subtile_0__pin_O_11_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_right_grid_left_width_0_height_0_subtile_0__pin_O_11_[0]
  PIN top_right_grid_left_width_0_height_0_subtile_0__pin_O_15_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_right_grid_left_width_0_height_0_subtile_0__pin_O_15_[0]
  PIN top_right_grid_left_width_0_height_0_subtile_0__pin_O_19_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END top_right_grid_left_width_0_height_0_subtile_0__pin_O_19_[0]
  PIN chanx_right_in[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[0]
  PIN chanx_right_in[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[1]
  PIN chanx_right_in[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[2]
  PIN chanx_right_in[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[3]
  PIN chanx_right_in[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[4]
  PIN chanx_right_in[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[5]
  PIN chanx_right_in[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[6]
  PIN chanx_right_in[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[7]
  PIN chanx_right_in[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[8]
  PIN chanx_right_in[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[9]
  PIN right_top_grid_bottom_width_0_height_0_subtile_0__pin_O_2_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_top_grid_bottom_width_0_height_0_subtile_0__pin_O_2_[0]
  PIN right_top_grid_bottom_width_0_height_0_subtile_0__pin_O_6_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_top_grid_bottom_width_0_height_0_subtile_0__pin_O_6_[0]
  PIN right_top_grid_bottom_width_0_height_0_subtile_0__pin_O_10_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_top_grid_bottom_width_0_height_0_subtile_0__pin_O_10_[0]
  PIN right_top_grid_bottom_width_0_height_0_subtile_0__pin_O_14_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_top_grid_bottom_width_0_height_0_subtile_0__pin_O_14_[0]
  PIN right_top_grid_bottom_width_0_height_0_subtile_0__pin_O_18_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_top_grid_bottom_width_0_height_0_subtile_0__pin_O_18_[0]
  PIN right_bottom_grid_top_width_0_height_0_subtile_0__pin_O_0_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_bottom_grid_top_width_0_height_0_subtile_0__pin_O_0_[0]
  PIN right_bottom_grid_top_width_0_height_0_subtile_0__pin_O_4_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_bottom_grid_top_width_0_height_0_subtile_0__pin_O_4_[0]
  PIN right_bottom_grid_top_width_0_height_0_subtile_0__pin_O_8_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_bottom_grid_top_width_0_height_0_subtile_0__pin_O_8_[0]
  PIN right_bottom_grid_top_width_0_height_0_subtile_0__pin_O_12_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_bottom_grid_top_width_0_height_0_subtile_0__pin_O_12_[0]
  PIN right_bottom_grid_top_width_0_height_0_subtile_0__pin_O_16_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END right_bottom_grid_top_width_0_height_0_subtile_0__pin_O_16_[0]
  PIN chany_bottom_in[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[0]
  PIN chany_bottom_in[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[1]
  PIN chany_bottom_in[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[2]
  PIN chany_bottom_in[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[3]
  PIN chany_bottom_in[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[4]
  PIN chany_bottom_in[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[5]
  PIN chany_bottom_in[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[6]
  PIN chany_bottom_in[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[7]
  PIN chany_bottom_in[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[8]
  PIN chany_bottom_in[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chany_bottom_in[9]
  PIN bottom_right_grid_left_width_0_height_0_subtile_0__pin_O_3_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_right_grid_left_width_0_height_0_subtile_0__pin_O_3_[0]
  PIN bottom_right_grid_left_width_0_height_0_subtile_0__pin_O_7_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_right_grid_left_width_0_height_0_subtile_0__pin_O_7_[0]
  PIN bottom_right_grid_left_width_0_height_0_subtile_0__pin_O_11_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_right_grid_left_width_0_height_0_subtile_0__pin_O_11_[0]
  PIN bottom_right_grid_left_width_0_height_0_subtile_0__pin_O_15_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_right_grid_left_width_0_height_0_subtile_0__pin_O_15_[0]
  PIN bottom_right_grid_left_width_0_height_0_subtile_0__pin_O_19_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_right_grid_left_width_0_height_0_subtile_0__pin_O_19_[0]
  PIN bottom_left_grid_right_width_0_height_0_subtile_0__pin_O_1_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_left_grid_right_width_0_height_0_subtile_0__pin_O_1_[0]
  PIN bottom_left_grid_right_width_0_height_0_subtile_0__pin_O_5_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_left_grid_right_width_0_height_0_subtile_0__pin_O_5_[0]
  PIN bottom_left_grid_right_width_0_height_0_subtile_0__pin_O_9_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_left_grid_right_width_0_height_0_subtile_0__pin_O_9_[0]
  PIN bottom_left_grid_right_width_0_height_0_subtile_0__pin_O_13_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_left_grid_right_width_0_height_0_subtile_0__pin_O_13_[0]
  PIN bottom_left_grid_right_width_0_height_0_subtile_0__pin_O_17_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END bottom_left_grid_right_width_0_height_0_subtile_0__pin_O_17_[0]
  PIN chanx_left_in[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[0]
  PIN chanx_left_in[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[1]
  PIN chanx_left_in[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[2]
  PIN chanx_left_in[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[3]
  PIN chanx_left_in[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[4]
  PIN chanx_left_in[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[5]
  PIN chanx_left_in[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[6]
  PIN chanx_left_in[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[7]
  PIN chanx_left_in[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[8]
  PIN chanx_left_in[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[9]
  PIN left_top_grid_bottom_width_0_height_0_subtile_0__pin_O_2_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_top_grid_bottom_width_0_height_0_subtile_0__pin_O_2_[0]
  PIN left_top_grid_bottom_width_0_height_0_subtile_0__pin_O_6_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_top_grid_bottom_width_0_height_0_subtile_0__pin_O_6_[0]
  PIN left_top_grid_bottom_width_0_height_0_subtile_0__pin_O_10_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_top_grid_bottom_width_0_height_0_subtile_0__pin_O_10_[0]
  PIN left_top_grid_bottom_width_0_height_0_subtile_0__pin_O_14_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_top_grid_bottom_width_0_height_0_subtile_0__pin_O_14_[0]
  PIN left_top_grid_bottom_width_0_height_0_subtile_0__pin_O_18_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_top_grid_bottom_width_0_height_0_subtile_0__pin_O_18_[0]
  PIN left_bottom_grid_top_width_0_height_0_subtile_0__pin_O_0_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_bottom_grid_top_width_0_height_0_subtile_0__pin_O_0_[0]
  PIN left_bottom_grid_top_width_0_height_0_subtile_0__pin_O_4_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_bottom_grid_top_width_0_height_0_subtile_0__pin_O_4_[0]
  PIN left_bottom_grid_top_width_0_height_0_subtile_0__pin_O_8_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_bottom_grid_top_width_0_height_0_subtile_0__pin_O_8_[0]
  PIN left_bottom_grid_top_width_0_height_0_subtile_0__pin_O_12_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_bottom_grid_top_width_0_height_0_subtile_0__pin_O_12_[0]
  PIN left_bottom_grid_top_width_0_height_0_subtile_0__pin_O_16_[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END left_bottom_grid_top_width_0_height_0_subtile_0__pin_O_16_[0]
  PIN ccff_head[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ccff_head[0]
  PIN chany_top_out[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[0]
  PIN chany_top_out[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[1]
  PIN chany_top_out[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[2]
  PIN chany_top_out[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[3]
  PIN chany_top_out[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[4]
  PIN chany_top_out[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[5]
  PIN chany_top_out[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[6]
  PIN chany_top_out[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[7]
  PIN chany_top_out[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[8]
  PIN chany_top_out[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_top_out[9]
  PIN chanx_right_out[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[0]
  PIN chanx_right_out[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[1]
  PIN chanx_right_out[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[2]
  PIN chanx_right_out[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[3]
  PIN chanx_right_out[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[4]
  PIN chanx_right_out[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[5]
  PIN chanx_right_out[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[6]
  PIN chanx_right_out[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[7]
  PIN chanx_right_out[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[8]
  PIN chanx_right_out[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[9]
  PIN chany_bottom_out[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[0]
  PIN chany_bottom_out[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[1]
  PIN chany_bottom_out[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[2]
  PIN chany_bottom_out[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[3]
  PIN chany_bottom_out[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[4]
  PIN chany_bottom_out[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[5]
  PIN chany_bottom_out[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[6]
  PIN chany_bottom_out[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[7]
  PIN chany_bottom_out[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[8]
  PIN chany_bottom_out[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chany_bottom_out[9]
  PIN chanx_left_out[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[0]
  PIN chanx_left_out[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[1]
  PIN chanx_left_out[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[2]
  PIN chanx_left_out[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[3]
  PIN chanx_left_out[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[4]
  PIN chanx_left_out[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[5]
  PIN chanx_left_out[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[6]
  PIN chanx_left_out[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[7]
  PIN chanx_left_out[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[8]
  PIN chanx_left_out[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[9]
  PIN ccff_tail[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ccff_tail[0]
  OBS
    LAYER TopMetal2 ;
      RECT 0.000000 0.000000 117.600000 128.520000 ;
    LAYER TopMetal1 ;
      RECT 0.000000 0.000000 117.600000 128.520000 ;
    LAYER Metal5 ;
      RECT 0.000000 0.000000 117.600000 128.520000 ;
    LAYER Metal4 ;
      RECT 0.000000 0.000000 117.600000 128.520000 ;
    LAYER Metal3 ;
      RECT 0.000000 0.000000 117.600000 128.520000 ;
    LAYER Metal2 ;
      RECT 0.000000 0.000000 117.600000 128.520000 ;
    LAYER Metal1 ;
      RECT 0.000000 0.000000 117.600000 128.520000 ;
  END
END sb_1__1_

END LIBRARY
