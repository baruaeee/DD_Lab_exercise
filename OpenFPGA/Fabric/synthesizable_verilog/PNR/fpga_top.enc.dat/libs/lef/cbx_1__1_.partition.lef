###############################################################
#  Generated by:      Cadence Innovus 23.31-s109_1
#  OS:                Linux x86_64(Host ID ei-vm-018.othr.de)
#  Generated on:      Sat Jun 21 02:18:26 2025
#  Design:            fpga_top
#  Command:           saveDesign fpga_top.enc -tcon
###############################################################

VERSION 5.8 ;

BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO cbx_1__1_
  CLASS BLOCK ;
  FOREIGN cbx_1__1_ 0.000000 0.000000 ;
  ORIGIN 0.000000 0.000000 ;
  SIZE 103.680000 BY 113.400000 ;
  SYMMETRY X Y R90 ;
  PIN pReset[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END pReset[0]
  PIN prog_clk[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END prog_clk[0]
  PIN chanx_left_in[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[0]
  PIN chanx_left_in[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[1]
  PIN chanx_left_in[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[2]
  PIN chanx_left_in[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[3]
  PIN chanx_left_in[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[4]
  PIN chanx_left_in[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[5]
  PIN chanx_left_in[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[6]
  PIN chanx_left_in[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[7]
  PIN chanx_left_in[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[8]
  PIN chanx_left_in[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_left_in[9]
  PIN chanx_right_in[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[0]
  PIN chanx_right_in[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[1]
  PIN chanx_right_in[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[2]
  PIN chanx_right_in[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[3]
  PIN chanx_right_in[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[4]
  PIN chanx_right_in[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[5]
  PIN chanx_right_in[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[6]
  PIN chanx_right_in[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[7]
  PIN chanx_right_in[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[8]
  PIN chanx_right_in[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END chanx_right_in[9]
  PIN ccff_head[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ccff_head[0]
  PIN chanx_left_out[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[0]
  PIN chanx_left_out[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[1]
  PIN chanx_left_out[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[2]
  PIN chanx_left_out[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[3]
  PIN chanx_left_out[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[4]
  PIN chanx_left_out[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[5]
  PIN chanx_left_out[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[6]
  PIN chanx_left_out[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[7]
  PIN chanx_left_out[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[8]
  PIN chanx_left_out[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_left_out[9]
  PIN chanx_right_out[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[0]
  PIN chanx_right_out[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[1]
  PIN chanx_right_out[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[2]
  PIN chanx_right_out[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[3]
  PIN chanx_right_out[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[4]
  PIN chanx_right_out[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[5]
  PIN chanx_right_out[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[6]
  PIN chanx_right_out[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[7]
  PIN chanx_right_out[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[8]
  PIN chanx_right_out[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END chanx_right_out[9]
  PIN top_grid_bottom_width_0_height_0_subtile_0__pin_I_2_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_grid_bottom_width_0_height_0_subtile_0__pin_I_2_[0]
  PIN top_grid_bottom_width_0_height_0_subtile_0__pin_I_6_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_grid_bottom_width_0_height_0_subtile_0__pin_I_6_[0]
  PIN top_grid_bottom_width_0_height_0_subtile_0__pin_I_10_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_grid_bottom_width_0_height_0_subtile_0__pin_I_10_[0]
  PIN top_grid_bottom_width_0_height_0_subtile_0__pin_I_14_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_grid_bottom_width_0_height_0_subtile_0__pin_I_14_[0]
  PIN top_grid_bottom_width_0_height_0_subtile_0__pin_I_18_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_grid_bottom_width_0_height_0_subtile_0__pin_I_18_[0]
  PIN top_grid_bottom_width_0_height_0_subtile_0__pin_I_22_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_grid_bottom_width_0_height_0_subtile_0__pin_I_22_[0]
  PIN top_grid_bottom_width_0_height_0_subtile_0__pin_I_26_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_grid_bottom_width_0_height_0_subtile_0__pin_I_26_[0]
  PIN top_grid_bottom_width_0_height_0_subtile_0__pin_I_30_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_grid_bottom_width_0_height_0_subtile_0__pin_I_30_[0]
  PIN top_grid_bottom_width_0_height_0_subtile_0__pin_I_34_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_grid_bottom_width_0_height_0_subtile_0__pin_I_34_[0]
  PIN top_grid_bottom_width_0_height_0_subtile_0__pin_I_38_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END top_grid_bottom_width_0_height_0_subtile_0__pin_I_38_[0]
  PIN bottom_grid_top_width_0_height_0_subtile_0__pin_I_0_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_grid_top_width_0_height_0_subtile_0__pin_I_0_[0]
  PIN bottom_grid_top_width_0_height_0_subtile_0__pin_I_4_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_grid_top_width_0_height_0_subtile_0__pin_I_4_[0]
  PIN bottom_grid_top_width_0_height_0_subtile_0__pin_I_8_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_grid_top_width_0_height_0_subtile_0__pin_I_8_[0]
  PIN bottom_grid_top_width_0_height_0_subtile_0__pin_I_12_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_grid_top_width_0_height_0_subtile_0__pin_I_12_[0]
  PIN bottom_grid_top_width_0_height_0_subtile_0__pin_I_16_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_grid_top_width_0_height_0_subtile_0__pin_I_16_[0]
  PIN bottom_grid_top_width_0_height_0_subtile_0__pin_I_20_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_grid_top_width_0_height_0_subtile_0__pin_I_20_[0]
  PIN bottom_grid_top_width_0_height_0_subtile_0__pin_I_24_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_grid_top_width_0_height_0_subtile_0__pin_I_24_[0]
  PIN bottom_grid_top_width_0_height_0_subtile_0__pin_I_28_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_grid_top_width_0_height_0_subtile_0__pin_I_28_[0]
  PIN bottom_grid_top_width_0_height_0_subtile_0__pin_I_32_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_grid_top_width_0_height_0_subtile_0__pin_I_32_[0]
  PIN bottom_grid_top_width_0_height_0_subtile_0__pin_I_36_[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END bottom_grid_top_width_0_height_0_subtile_0__pin_I_36_[0]
  PIN ccff_tail[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ccff_tail[0]
  OBS
    LAYER TopMetal2 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
    LAYER TopMetal1 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
    LAYER Metal5 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
    LAYER Metal4 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
    LAYER Metal3 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
    LAYER Metal2 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
    LAYER Metal1 ;
      RECT 0.000000 0.000000 103.680000 113.400000 ;
  END
END cbx_1__1_

END LIBRARY
